# Keil uVision project FindMy.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: FindMy +hex
  AfterMake: fromelf.exe .\Objects\FindMy.axf --i32combined --output .\bin\FindMy.hex
  AfterMake: fromelf -c -a -d -e -v -o FindMy.asm ./Objects/FindMy.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: DEBUG_INFO=3  CFG_CP  OSAL_CBTIMER_NUM_TASKS=1 MTU_SIZE=247 HOST_CONFIG=3 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0  _BUILD_FOR_DTM_=0  DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_SLEEP DEF_GAPBOND_MGR_ENABLE=0 USE_FS=0 MAX_NUM_LL_CONN=1
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: ..\components\inc;..\components\ble\controller;..\components\osal\include;..\components\common;..\components\ble\include;..\components\ble\hci;..\components\ble\host;..\components\Profiles\ota_app;..\components\Profiles\DevInfo;..\components\Profiles\SimpleProfile;..\components\Profiles\Roles;.\source;..\components\libraries\crc16;..\components\driver\watchdog;..\components\driver\clock;..\components\arch\cm0;..\components\driver\pwrmgr;..\components\driver\uart;..\components\driver\gpio;..\components\driver\timer;..\misc;..\components\driver\log;..\components\libraries\cliface;..\components\driver\key;..\components\driver\pwm;..\components\driver\flash;..\components\libraries\fs;..\components\driver\led_light
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./: main.c
  group driver
    ../components/driver/uart/: uart.c
    ../components/driver/clock/: clock.c
    ../components/driver/gpio/: gpio.c
    ../components/driver/timer/: timer.c
    ../components/driver/watchdog/: watchdog.c
    ../components/driver/pwrmgr/: pwrmgr.c
    ../components/driver/log/: my_printf.c
    ../components/driver/key/: key.c
    ../components/driver/pwm/: pwm.c
    ../components/osal/snv/: osal_snv.c
    ../components/driver/flash/: flash.c
    ../components/driver/led_light/: led_light.c
    ../components/libraries/fs/: fs.c fs.h
  group profile
    ../components/profiles/Roles/: gap.c broadcaster.c observer.c
  group jump
    ../misc/: jump_table.c
  group lib
    ../lib/: rf.lib ble_host.lib
  group FindMy
    ./source/: OSAL_SimpleBLEPeripheral.c FindMy.c SimpleBLEPeripheral_Main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.2
